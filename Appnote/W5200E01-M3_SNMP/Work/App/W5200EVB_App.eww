<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\W5200EVB_App.ewp</path>
  </project>
  <batchBuild/>
</workspace>


